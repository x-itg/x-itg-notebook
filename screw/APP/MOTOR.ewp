# IAR project MOTOR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103V8 ST STM32F103V8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\STM32F10x_FWLib\inc; ..\USER; ..\CORE; ..\Libraries\MSD\Inc; ..\Libraries\STM32_USB-FS-Device_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ES120.hex
  ILINK.IlinkOutputFile: ES120.out
  ILINK.IlinkIcfFile: MOTOR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_MD
  ILINK.IlinkOutputFile: MOTOR.out
  group CMSISI
    ../CORE/: startup_stm32f10x_md.s
    ../USER/: system_stm32f10x.c
  group LIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MSD
    ../Libraries/MSD/Src/: USB_bot.c USB_desc.c USB_istr.c USB_prop.c USB_pwr.c USB_scsi.c
  group USB-FS-Devier
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USER
    ../USER/: adc.c ctrl.c delay.c Disk.c hardware.c iic.c L3G4200D.c main.c oled.c own_sprintf.c stm32f10x_it.c sys.c UI.c
